# Keil uVision project ODrive.uvprojx, settings and files
target ODrive (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ODrive +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;                                     ../Drivers/STM32F4xx_HAL_Driver/Inc;                                     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                     ../Drivers/CMSIS/Include;                                     ..\User\APP;                                     ..\User\Function;                                     ..\User\MCUDriver;                                     ..\User\PeripheralsDriver;                                     ..\User\Framework;                                     ..\User\RTT;                                     ..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../: README.txt
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../User/APP/: APPMain.c APPMain.h
  group Function
    ../User/Function/: FunctionMain.c FunctionMain.h
  group MCUDriver
    ../User/MCUDriver/: MCUDriverMain.c MCUDriverMain.h TIM1PWM.c TIM1PWM.h TIM3Encoder.c TIM3Encoder.h Timer.c Timer.h MotorGPIO.c MotorGPIO.h GPIONVIC.c GPIONVIC.h ADC1.c ADC1.h LEDGPIO.c LEDGPIO.h
  group PERDriver
    ../User/PeripheralsDriver/: PerDriverMain.c PerDriverMain.h SvpwmConfig.c SvpwmConfig.h FOCConfig.c FOCConfig.h SpeedPIDConfig.c SpeedPIDConfig.h PositionPIDConfig.c PositionPIDConfig.h LEDConfig.c LEDConfig.h
  group Framework
    ../User/Framework/: FOC.c FOC.h Svpwm.c Svpwm.h SpeedPID.c SpeedPID.h PositionPID.c PositionPID.h LEDControl.c LEDControl.h
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
