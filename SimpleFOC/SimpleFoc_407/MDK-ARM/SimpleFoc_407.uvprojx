# Keil uVision project SimpleFoc_407.uvprojx, settings and files
target SimpleFoc_407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SimpleFoc_407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User\APP;..\User\Framework;..\User\Function;..\User\MCUDriver;..\User\PeripheralsDriver;..\User\Protocol;..\User\RTT;..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../User/APP/: APPMain.c APPMain.h
  group Function
    ../User/Function/: AngleCalibrationFunc.c AngleCalibrationFunc.h FunctionMain.c FunctionMain.h
  group MCUDriver
    ../User/MCUDriver/: ADC1.c ADC1.h LEDGPIO.c LEDGPIO.h MCUDriverMain.c MCUDriverMain.h MotorGPIO.c MotorGPIO.h SPI2.c SPI2.h TIM3.c TIM3.h TIM4.c TIM4.h Timer.c Timer.h SPI1.c SPI1.h
  group PeripheralsDriver
    ../User/PeripheralsDriver/: PerDriverMain.c PerDriverMain.h FOCConfig.c FOCConfig.h LEDConfig.c LEDConfig.h SvpwmConfig.c SvpwmConfig.h TLE5012BConfig.c TLE5012BConfig.h PositionPIDConfig.c PositionPIDConfig.h SpeedPIDConfig.c SpeedPIDConfig.h
  group Framework
    ../User/Framework/: FOC.c FOC.h LEDControl.c LEDControl.h RingBuffer.c RingBuffer.h Svpwm.c Svpwm.h TLE5012B.c TLE5012B.h SpeedPID.c SpeedPID.h PositionPID.c PositionPID.h
  group Protocol
    ../User/Protocol/: ProtocolMain.c ProtocolMain.h
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.4.0
