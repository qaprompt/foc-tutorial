# Keil uVision project FOC-V2.0.1.uvprojx, settings and files
target FOC-V2.0.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC-V2.0.1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\User\APP; ..\User\Framework; ..\User\Function; ..\User\MCUDriver; ..\User\PeripheralsDriver; ..\User\RTT; ..\Drivers\CMSIS\DSP\Include; ..\StemWin\Config; ..\StemWin\inc; ..\StemWin\Lib; ..\StemWin\OS; ..\StemWin\UI; ..\User\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c crc.c dma.c i2c.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group APP
    ../User/APP/: APPMain.c APPMain.h
  group Function
    ../User/Function/: FunctionMain.c FunctionMain.h GUIFunc.c GUIFunc.h
  group MCUDriver
    ../User/MCUDriver/: MCUDriverMain.c MCUDriverMain.h Timer.c Timer.h LEDGPIO.c LEDGPIO.h TIM1PWM.c TIM1PWM.h TIM4Encoder.c TIM4Encoder.h GPIONVIC.c GPIONVIC.h MotorGPIO.c MotorGPIO.h ADC1.c ADC1.h IIC1.c IIC1.h KeyGpio.c KeyGpio.h
  group PeripheralsDriver
    ../User/PeripheralsDriver/: PerDriverMain.c PerDriverMain.h LEDConfig.c LEDConfig.h SvpwmConfig.c SvpwmConfig.h FOCConfig.c FOCConfig.h SpeedPIDConfig.c SpeedPIDConfig.h PositionPIDConfig.c PositionPIDConfig.h OLEDConfig.c OLEDConfig.h KeyConfig.c KeyConfig.h
  group Framework
    ../User/Framework/: LEDControl.c LEDControl.h Svpwm.c Svpwm.h FOC.c FOC.h SpeedPID.c SpeedPID.h PositionPID.c PositionPID.h OLED.c OLED.h KeyScan.c KeyScan.h PageGUI.c PageGUI.h
  group StemWin
    ../StemWin/Lib/: STemWin532_CM4_Keil.lib
    ../StemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../StemWin/OS/: GUI_X.c
    ../StemWin/UI/: Logo.c About.c About2.c Wave.c
  group GUI
    ../User/GUI/: GUIInputEvent.c GUIInputEvent.h LogoPage.c LogoPage.h AboutPage.c AboutPage.h About2Page.c About2Page.h WavePage.c WavePage.h
software components: CMSIS:CORE 4.3.0
