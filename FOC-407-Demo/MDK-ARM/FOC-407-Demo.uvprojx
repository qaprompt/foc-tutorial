# Keil uVision project FOC-407-Demo.uvprojx, settings and files
target FOC-407-Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC-407-Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ../Core/Inc;                                       ../Drivers/STM32F4xx_HAL_Driver/Inc;                                       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                       ../Drivers/CMSIS/Include;                                       ..\User\APP;                                       ..\User\Framework;                                       ..\User\Function;                                       ..\User\MCUDriver;                                       ..\User\PeripheralsDriver;                                       ..\User\RTT;                                       ..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../User/APP/: APPMain.c APPMain.h
  group Function
    ../User/Function/: FunctionMain.c FunctionMain.h AngleCalibrationFunc.c AngleCalibrationFunc.h
  group MCUDriver
    ../User/MCUDriver/: MCUDriverMain.c MCUDriverMain.h Motor1ADC1.c Motor1ADC1.h Motor1GPIO.c Motor1GPIO.h Motor1TIM1Pwm.c Motor1TIM1Pwm.h Motor1SPI1.c Motor1SPI1.h Timer.c Timer.h Uart1.c Uart1.h LEDGPIO.c LEDGPIO.h Motor2GPIO.c Motor2GPIO.h Motor2ADC2.c Motor2ADC2.h Motor2SPI2.c Motor2SPI2.h Motor2TIM3Pwm.c Motor2TIM3Pwm.h
  group PeripheralsDriver
    ../User/PeripheralsDriver/: LEDConfig.c LEDConfig.h PerDriverMain.c PerDriverMain.h Motor1FOCConfig.c Motor1FOCConfig.h Motor1SvpwmConfig.c Motor1SvpwmConfig.h Motor1TLE5012BConfig.c Motor1TLE5012BConfig.h Motor2TLE5012BConfig.c Motor2TLE5012BConfig.h Motor2FOCConfig.c Motor2FOCConfig.h Motor2SvpwmConfig.c Motor2SvpwmConfig.h Motor1SpeedPIDConfig.c Motor1SpeedPIDConfig.h Motor1PositionPIDConfig.c Motor1PositionPIDConfig.h Motor2PositionPIDConfig.c Motor2PositionPIDConfig.h Motor2SpeedPIDConfig.c Motor2SpeedPIDConfig.h
  group Framework
    ../User/Framework/: FOC.c FOC.h LEDControl.c LEDControl.h PositionPID.c PositionPID.h RingBuffer.c RingBuffer.h SpeedPID.c SpeedPID.h Svpwm.c Svpwm.h TLE5012B.c TLE5012B.h
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
